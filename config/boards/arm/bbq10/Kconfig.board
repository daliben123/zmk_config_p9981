## config/boards/arm/bbq10/Kconfig.board
```kconfig
# Copyright (c) 2025 daliben123
# SPDX-License-Identifier: MIT

config BOARD_BBQ10
    bool "bbq10"
    depends on SOC_NRF52840_QIAA
```
